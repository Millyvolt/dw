# Keil uVision project DWM1004C_MDK.uvprojx, settings and files
target DWM1004C_MDK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L041G6Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DWM1004C +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=131072,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32L041xx
  c include: ../Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc;    ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;    ../Drivers/CMSIS/Include;    ../Drivers/deca_driver;    ../Src/cmd;    ../Src/config;    ../Src/instance;    ../Src/mems;    ../Src/Port;    ../Src/utils;    ../Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l041xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_crc.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_i2c.c stm32l0xx_ll_dma.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_pwr.c stm32l0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/deca_driver
    ../Drivers/deca_driver/: deca_device.c deca_params_init.c
  group Application/cmd
    ../Src/cmd/: cmd.c cmd_fn.c cmd_uart_rx.c
  group Application/config
    ../Src/config/: config.c
  group Application/instance
    ../Src/instance/: instance.c
  group Application/mems
    ../Src/mems/: lis3dh.c
  group Application/Port
    ../Src/Port/: deca_sleep.c deca_spi.c deca_uart.c port_platform.c
  group Application/utils
    ../Src/utils/: translate.c
software components: CMSIS:CORE 4.3.0
